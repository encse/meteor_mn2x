options:
  parameters:
    category: '[Meteor]'
    comment: Ported from Satdump
    generate_options: hb
    id: oqpsk_demodulator
    output_language: python
    title: OQPSK Demodulator
  states: {}

blocks:
- name: pipeline_sample_rate
  id: variable
  parameters:
    value: '144000'
  states: {}
- name: rrc_alpha
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: '72000'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-3'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0 / (2.0 * math.pi) * pipeline_sample_rate
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '0.002'
  states: {}
- name: digital_mpsk_snr_est_cc_0
  id: digital_mpsk_snr_est_cc
  parameters:
    alpha: '0.001'
    tag_nsamples: '10000'
    type: '2'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: digital.constellation_qpsk().base()
    damping: '0.707'
    loop_bw: '0.02'
    max_dev: '0.05'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1'
    ted_type: digital.TED_MOD_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.root_raised_cosine(1.0, pipeline_sample_rate, sym_rate, alpha=rrc_alpha, ntaps=35)
    type: ccc
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from gnuradio.filter import firdes
  states: {}
- name: import_1_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: soft_symbols
    type: complex
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: doppler_hz
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_1_0
  id: pad_sink
  parameters:
    label: snr_db
    optional: 'True'
    type: float
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: sample_rate
    interp: pipeline_sample_rate
    type: ccc
  states: {}
- name: sample_rate
  id: parameter
  parameters:
    type: intx
    value: '0'
  states: {}
- name: tag_value_to_float_0
  id: tag_value_to_float
  parameters:
    tag_key: snr
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: costas
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: fir
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: symbol_synced
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: oqpsk_delay
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    comment: |-
      # 

      We delay one branch by half a symbol to convert the OQPSK stream into a QPSK-like symbol stream before symbol synchronization.

      At this stage we do not necessarily know whether the delayed branch is the correct one. The output may therefore contain correctly paired symbols, such as:

        I0 Q0, I1 Q1, I2 Q2, ...

      or symbols shifted by one symbol on one branch, such as:

        I1 Q0, I2 Q1, I3 Q2, ...

      This is acceptable for symbol synchronization, because the I and Q decision points are now aligned in time. The remaining ambiguity must be resolved later in the decoder, when searching for the sync word.
    stream_id: costas
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: symbol_synced
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: fir
  states: {}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: oqpsk_delay
  states: {}

connections:
- [analog_agc_xx_0, '0', fir_filter_xxx_1, '0']
- [blocks_complex_to_float_0_0, '0', blocks_float_to_complex_0_0, '0']
- [blocks_complex_to_float_0_0, '1', blocks_delay_0_0_0, '0']
- [blocks_delay_0_0_0, '0', blocks_float_to_complex_0_0, '1']
- [blocks_float_to_complex_0_0, '0', virtual_sink_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', pad_sink_1, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_0, '0']
- [digital_costas_loop_cc_0, '1', blocks_multiply_const_vxx_0, '0']
- [digital_costas_loop_cc_0, '2', blocks_null_sink_0_0, '0']
- [digital_costas_loop_cc_0, '3', blocks_null_sink_0, '0']
- [digital_mpsk_snr_est_cc_0, '0', tag_value_to_float_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_mpsk_snr_est_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', virtual_sink_0_0_0, '0']
- [fir_filter_xxx_1, '0', virtual_sink_0_0, '0']
- [pad_source_1, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_agc_xx_0, '0']
- [tag_value_to_float_0, '0', pad_sink_1_0, '0']
- [virtual_source_0, '0', blocks_complex_to_float_0_0, '0']
- [virtual_source_0_0, '0', pad_sink_0_0, '0']
- [virtual_source_0_1, '0', digital_costas_loop_cc_0, '0']
- [virtual_source_0_2, '0', digital_symbol_sync_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
